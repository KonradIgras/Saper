# Keil uVision project saper.uvprojx, settings and files
target 'FRDM-KL05ZJ (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: saper
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c main.h mouse.c mouse.h graphics.c logic.c oled.c random.c spi.c graphics.h logic.h oled.h random.h spi.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
